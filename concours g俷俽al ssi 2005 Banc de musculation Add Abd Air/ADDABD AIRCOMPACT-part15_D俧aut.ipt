# Autodesk Inventor part: ADDABD AIRCOMPACT-part15_Défaut
## iProperties
Shininess: 64.0
Length Units: 11269
Angle Units: 11279
Time Units: 11290
Mass Units: 11283
Length Display Precision: 3
Angle Display Precision: 2
Compacted: True
Part Number: ADDABD AIRCOMPACT-part15_Défaut
Document SubType Name: Modeling
Created: 2006-01
Material: Par défaut
Designer: riri
Density: 0.0
Volumn: 0.0
Area: 0.0
PropertySet Name: Model Information
Control State: 0
Master: False
Checked Out: False
Author: riri
## Feature names
1. Base1
